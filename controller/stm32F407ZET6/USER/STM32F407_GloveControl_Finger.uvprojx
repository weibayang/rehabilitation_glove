# Keil uVision project STM32F407_GloveControl_Finger.uvprojx, settings and files
target STM32F407_GloveControl_Finger (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407_GloveControl_Finger +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\FWLIB\inc;..\CORE;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\APP\LED;..\APP\I2Csml;..\APP\PCA9685;..\APP\TLC1543;..\APP\USART_DMA;..\APP\TIM;..\APP\GMValueDef;..\APP\SPIADS1256;..\APP\USART;..\APP\MyFunc;..\APP\STMFlash;..\APP\SPIAD7606;..\FWLIB\src;..\..\STM32_Vision9—20211213—手套动作实战版
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_flash.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group APP
    ../APP/LED/: LED.c
    ../APP/I2Csml/: I2Csml.c
    ../APP/PCA9685/: PCA9685.c
    ../APP/TIM/: TIM.c
    ../APP/GMValueDef/: GMValueDef.c
    ../APP/USART/: Usart.c
    ../APP/MyFunc/: MyFunc.c
    ../APP/STMFlash/: stmflash.c
    ../APP/SPIAD7606/: SPIAD7606.c
    ./: GetAngle.c
